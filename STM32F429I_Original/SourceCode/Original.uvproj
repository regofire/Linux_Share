# Keil uVision project Original.uvproj, settings and files
target Original (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Original +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .\Lib;.\Lib\CMSIS;.\Lib\MyLib;.\Lib\STM32F4xx_StdPeriph_Driver\inc;.\Usr;..\SourceCode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Usr
    ./Usr/: main.c
  group Sys
    ./Sys/: startup_stm32f429_439xx.s
